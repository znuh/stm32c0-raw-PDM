options:
  parameters:
    author: hunz
    generate_options: no_gui
    id: pdm_to_wav
    output_language: python
    run_options: run
    title: PDM to WAV
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '6'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: input_fname
  id: variable
  parameters:
    value: '"input_file"'
  states: {}
- name: output_fname
  id: variable
  parameters:
    value: '"output_file"'
  states: {}
- name: pdm_srate
  id: variable
  parameters:
    value: '4800000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: pdm_srate/(decim1*decim2)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_fname
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: output_fname
    format: FORMAT_WAV
    samp_rate: int(samp_rate)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 300e3
    decim: decim1
    gain: '1'
    samp_rate: pdm_srate
    type: fir_filter_fff
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 78e3
    decim: decim2
    gain: '1'
    samp_rate: pdm_srate/decim1
    type: fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    type: float
    update_time: 1/30
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
